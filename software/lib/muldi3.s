#NO_APP
	.file	"muldi3.c"
	.text
	.globl	__mulsi3
	.align	2
	.globl	__muldi3
	.type	__muldi3, @function
__muldi3:
	lea (-64,%sp),%sp
	move.l %d3,-(%sp)
	move.l %d2,-(%sp)
	move.l 76(%sp),24(%sp)
	move.l 80(%sp),28(%sp)
	move.l 84(%sp),16(%sp)
	move.l 88(%sp),20(%sp)
	move.l 28(%sp),%d0
	move.l %d0,%d1
	and.l #65535,%d1
	move.l %d1,64(%sp)
	move.l 28(%sp),%d0
	clr.w %d0
	swap %d0
	move.l %d0,60(%sp)
	move.l 20(%sp),%d0
	move.l %d0,%d1
	and.l #65535,%d1
	move.l %d1,56(%sp)
	move.l 20(%sp),%d0
	clr.w %d0
	swap %d0
	move.l %d0,52(%sp)
	move.l 56(%sp),-(%sp)
	move.l 68(%sp),-(%sp)
	jsr __mulsi3
	addq.l #8,%sp
	move.l %d0,48(%sp)
	move.l 52(%sp),-(%sp)
	move.l 68(%sp),-(%sp)
	jsr __mulsi3
	addq.l #8,%sp
	move.l %d0,44(%sp)
	move.l 56(%sp),-(%sp)
	move.l 64(%sp),-(%sp)
	jsr __mulsi3
	addq.l #8,%sp
	move.l %d0,40(%sp)
	move.l 52(%sp),-(%sp)
	move.l 64(%sp),-(%sp)
	jsr __mulsi3
	addq.l #8,%sp
	move.l %d0,68(%sp)
	move.l 48(%sp),%d0
	clr.w %d0
	swap %d0
	add.l %d0,44(%sp)
	move.l 40(%sp),%d0
	add.l %d0,44(%sp)
	move.l 44(%sp),%d1
	cmp.l 40(%sp),%d1
	jcc .L2
	add.l #65536,68(%sp)
.L2:
	move.l 44(%sp),%d0
	clr.w %d0
	swap %d0
	add.l 68(%sp),%d0
	move.l %d0,8(%sp)
	move.l 44(%sp),%d0
	and.l #65535,%d0
	move.l %d0,%d1
	swap %d1
	clr.w %d1
	move.l 48(%sp),%d0
	and.l #65535,%d0
	add.l %d1,%d0
	move.l %d0,12(%sp)
	move.l 8(%sp),%d0
	move.l 12(%sp),%d1
	move.l %d0,32(%sp)
	move.l %d1,36(%sp)
	move.l 32(%sp),%d0
	move.l %d0,%d2
	move.l 28(%sp),%d0
	move.l 16(%sp),%d1
	move.l %d1,-(%sp)
	move.l %d0,-(%sp)
	jsr __mulsi3
	addq.l #8,%sp
	move.l %d0,%d3
	move.l 24(%sp),%d0
	move.l 20(%sp),%d1
	move.l %d1,-(%sp)
	move.l %d0,-(%sp)
	jsr __mulsi3
	addq.l #8,%sp
	add.l %d3,%d0
	add.l %d2,%d0
	move.l %d0,32(%sp)
	move.l 32(%sp),%a0
	move.l 36(%sp),%a1
	move.l %a0,%d0
	move.l %a1,%d1
	move.l (%sp)+,%d2
	move.l (%sp)+,%d3
	lea (64,%sp),%sp
	rts
	.size	__muldi3, .-__muldi3
	.ident	"GCC: (Ubuntu 10.2.0-5ubuntu1~20.04) 10.2.0"
	.section	.note.GNU-stack,"",@progbits
